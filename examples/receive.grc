options:
  parameters:
    author: Daniel Estévez
    generate_options: qt_gui
    id: receive
    output_language: python
    title: Example HL2 receiver
  states: {}

blocks:
- name: freq
  id: variable_qtgui_entry
  parameters:
    label: Frequency (Hz)
    type: int
    value: '7000000'
  states: {}
- name: interface
  id: variable
  parameters:
    value: '''eth0'''
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '384000'
  states: {}
- name: blocks_null_source_0
  id: blocks_null_source
  parameters:
    type: complex
  states: {}
- name: hermeslite2_NB_0
  id: hermeslite2_NB
  parameters:
    AGC: 'False'
    Intfc: interface
    LNAG: '18'
    MACAddr: '"*"'
    PA: 'False'
    PTTRx: 'True'
    PTTTx: 'True'
    PTTmode: '0'
    Q5: 'False'
    Rx0F: freq
    Rx1F: '7200000'
    Rx2F: '7200000'
    Rx3F: '7200000'
    Rx4F: '7200000'
    Rx5F: '7200000'
    Rx6F: '7200000'
    Rx7F: '7200000'
    RxSmp: '384000'
    TxDrive: '0'
    TxF: freq
    Verbose: '0'
    num_outputs: '1'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: freq
    fftsize: '4096'
    type: complex
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [blocks_null_source_0, '0', hermeslite2_NB_0, '0']
- [hermeslite2_NB_0, '0', qtgui_freq_sink_x_0, '0']

metadata:
  file_format: 1
